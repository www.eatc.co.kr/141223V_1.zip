# Autodesk Inventor part: 부시
## iProperties
Created: 2013-06
Part Number: 부시
Document SubType Name: Modeling
Designer: SeoGD™[esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™[esajin.kr]
