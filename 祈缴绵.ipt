# Autodesk Inventor part: 샤프트
## iProperties
Created: 2013-06
Part Number: 샤프트
Document SubType Name: Modeling
Designer: SeoGD™[esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™[esajin.kr]
