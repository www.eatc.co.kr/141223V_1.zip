# Autodesk Inventor part: 본체
## iProperties
Created: 2013-06
Part Number: 본체
Document SubType Name: Modeling
Designer: SeoGD™[esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™[esajin.kr]
