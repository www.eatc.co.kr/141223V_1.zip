# Autodesk Inventor part: 축 커버
## iProperties
Created: 2013-06
Part Number: 축 커버
Document SubType Name: Modeling
Designer: SeoGD™[esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™[esajin.kr]
